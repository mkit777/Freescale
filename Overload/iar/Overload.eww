<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Overload_K60DZ10.ewp</path>
  </project>
  <batchBuild></batchBuild>
</workspace>